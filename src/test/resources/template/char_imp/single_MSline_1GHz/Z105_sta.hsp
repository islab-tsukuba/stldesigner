*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z105 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z105
.model Z105 w modeltype=RLGC, n=1
+ Lo =
+ 6.19555667153e-07
+ Co =
+ 5.55069254679e-11
+ Ro =
+ 2.34576589256
+ Go =
+ 0
+ Rs =
+ 0.000877013263678
+ Gd =
+ 5.86918509807e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z105 Length=0.5

* End of File
