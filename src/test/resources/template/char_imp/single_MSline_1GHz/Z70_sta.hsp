*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z70 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z70
.model Z70 w modeltype=RLGC, n=1
+ Lo =
+ 4.27450257642e-07
+ Co =
+ 8.69413391713e-11
+ Ro =
+ 0.746380056725
+ Go =
+ 0
+ Rs =
+ 0.000351078212115
+ Gd =
+ 9.54818990436e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z70 Length=0.5

* End of File
