*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z120 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z120
.model Z120 w modeltype=RLGC, n=1
+ Lo =
+ 6.91002555505e-07
+ Co =
+ 4.846211769e-11
+ Ro =
+ 3.78931413414
+ Go =
+ 0
+ Rs =
+ 0.00117073173428
+ Gd =
+ 5.04413202204e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z120 Length=0.5

* End of File
