*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z75 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z75
.model Z75 w modeltype=RLGC, n=1
+ Lo =
+ 4.56261825973e-07
+ Co =
+ 8.04088922366e-11
+ Ro =
+ 0.879662209711
+ Go =
+ 0
+ Rs =
+ 0.000404583174124
+ Gd =
+ 8.78153723867e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z75 Length=0.5

* End of File
