*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z45 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z45
.model Z45 w modeltype=RLGC, n=1
+ Lo =
+ 2.85374562796e-07
+ Co =
+ 1.40348045784e-10
+ Ro =
+ 0.324086077262
+ Go =
+ 0
+ Rs =
+ 0.000172666298878
+ Gd =
+ 1.59152454352e-11
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z45 Length=0.5

* End of File
