*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z100 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z100
.model Z100 w modeltype=RLGC, n=1
+ Lo =
+ 5.91904602285e-07
+ Co =
+ 5.869372344e-11
+ Ro =
+ 1.97044334975
+ Go =
+ 0
+ Rs =
+ 0.000766698593327
+ Gd =
+ 6.24086019201e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z100 Length=0.5

* End of File
