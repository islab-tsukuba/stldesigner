*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z95 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z95
.model Z95 w modeltype=RLGC, n=1
+ Lo =
+ 5.62293773516e-07
+ Co =
+ 6.24768733302e-11
+ Ro =
+ 1.64203612479
+ Go =
+ 0
+ Rs =
+ 0.000678868777132
+ Gd =
+ 6.68249354193e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z95 Length=0.5

* End of File
