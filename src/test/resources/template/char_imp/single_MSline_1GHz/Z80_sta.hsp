*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z80 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z80
.model Z80 w modeltype=RLGC, n=1
+ Lo =
+ 4.83131524336e-07
+ Co =
+ 7.50732904242e-11
+ Ro =
+ 1.026272578
+ Go =
+ 0
+ Rs =
+ 0.000460049348924
+ Gd =
+ 8.15696478835e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z80 Length=0.5

* End of File
