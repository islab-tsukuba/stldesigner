*** Created by ADS, Agilent EEsof ***
*** HSPICE netlist file for static W-element data ***

.subckt ckt_Z110 in1 inref out1 outref Length=1
W1 in1 inref out1 outref N=1 L=Length RLGCMODEL=Z110
.model Z110 w modeltype=RLGC, n=1
+ Lo =
+ 6.43143130045e-07
+ Co =
+ 5.30017428741e-11
+ Ro =
+ 2.73672687466
+ Go =
+ 0
+ Rs =
+ 0.000962665582528
+ Gd =
+ 5.57582154389e-12
.ends

* Example Usage
* X1 in1 inref out1 outref ckt_Z110 Length=0.5

* End of File
